# Keil uVision project test_sdk.uvproj, settings and files
target LPC1114_sdk_test (ARM-ADS)
  device: LPC1114x301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: test_sdk +hex
  AfterMake: fromelf.exe --bin -o  "$L@L.bin" "#L"
  c flags: Optim=1
  c include: ..\inc;..\inc;..\drv\Blinky\inc;..\drv\GPIO\inc;..\drv\I2C_EEPROM\inc;..\drv\TemperatureSensor\inc;..\drv\UART\inc;..\drv\USB_Mem\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Startup
    ./: startup_LPC11xx.s
  group user
    ./user/: main.c
  group header
    ../inc/: GPIO.H
  group src
    ../src/: GPIO.C CLKCONFIG.C TIMER16.C UART.C RETARGET.C
  group sys
    ../src/: CORE_CM0.C SYSTEM_LPC11XX.C
